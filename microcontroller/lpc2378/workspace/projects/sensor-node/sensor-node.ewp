# IAR project sensor-node.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: LPC2378 NXP LPC2378
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 1
  General.FPU2: 0
  ICCARM.CCDefines: IAR_LPC_2378_SK
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\INC\NXP; include; ..\..\bsp\include; ..\..\Micrium\Software\ucos-ii\ports\arm\generic\iar; ..\..\Micrium\Software\ucos-ii\source; ..\..\Micrium\Software\uc-lib; ..\..\Micrium\Software\uc-cpu; ..\..\Micrium\Software\uc-cpu\arm\IAR
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: a.srec
  ILINK.IlinkOutputFile: a.out
  ILINK.IlinkIcfFile: config\LPC2378_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app/include
    include/: os_cfg.h xbee.h
  group app/src
    src/: main.c xbee.c
  group bsp/include
    ../../bsp/include/: accelerometer.h adc.h board.h bsp.h buttons.h can.h delay.h drv_glcd.h lcd.h leds.h median_filter.h potentiometer.h timers.h uart_polled.h
  group bsp/src
    ../../bsp/src/: accelerometer.c adc.c bsp.c buttons.c can.c delay.c lcd.c leds.c median_filter.c potentiometer.c timers.c uart_polled.c
  group bsp/src/lcd
    ../../bsp/src/lcd/: drv_glcd.c glcd_ll.c
  group bsp/src/lcd/fonts
    ../../bsp/src/lcd/fonts/: Terminal_9_12x6.c
  group Micrium/uC/CPU
    ../../Micrium/Software/uC-CPU/ARM/IAR/: cpu.h cpu_a.s
    ../../Micrium/Software/uC-CPU/: cpu_def.h
  group Micrium/uC/LIB
    ../../Micrium/Software/uC-LIB/: lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group Micrium/uC/OS-II/Port
    ../../Micrium/Software/uCOS-II/Ports/ARM/Generic/IAR/: cstartup.s os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c os_dcc.c osutils.c osutils.h
  group Micrium/uC/OS-II/Source
    ../../Micrium/Software/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
